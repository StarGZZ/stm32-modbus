# Keil uVision project mod_led.uvprojx, settings and files
target mod_led (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\..\STM32F0308_test;..\Libraries;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\MDK-ARM;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Device\ST\STM32F0xx\Source;..\modbus\ascii;..\modbus\functions;..\modbus\include;..\modbus\port;..\modbus\rtu;..\modbus\tcp;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_usart.c
  group User
    ../USER/: led.c systick.c key.c RS485.c dial_switch.c
  group modbus
    ../modbus/ascii/: mbascii.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/: mb.c
  group port
    ../modbus/port/: port.c portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.1.0
